# Repository felixfelix-bot/cycle-without-chain (continued)

## KiCad design hardware/powerboard-reva/powerboard-reva.kicad_pcb (continued)

Schematic: brake-switch-harness.kicad_sch, OFFBOARD supervised switch end-of-line network - candidate

Parts:
R124, R126: 4k7 1% EOL OFFBOARD; R_0805_2012Metric
R125, R127: 10k 1% EOL OFFBOARD; R_0805_2012Metric
SW1, SW2: NC_RELEASE_OPEN_ON_BRAKE_UNSELECTED; SW_SPST_TL3305A

Connections:
LEFT_SWITCH_EOL: R124.2, R125.1, SW1.1 (A)
LEFT_SWITCH_EXT: R124.1; also elsewhere on the board
PGND: R125.2, R127.2, SW1.2 (B), SW2.2 (B); also elsewhere on the board
RIGHT_SWITCH_EOL: R126.2, R127.1, SW2.1 (A)
RIGHT_SWITCH_EXT: R126.1; also elsewhere on the board

Notes on the sheet:
OFFBOARD parts must live at lever, not board. NC contact opens on rider braking. No brake cable modification.
Switch symbol drawn open (braking). Model cables unplugged by removing BOTH EOL resistors and switch.
Welded contact or resistor short can imitate release; FSR plausibility is firmware only, not independent safety.

Schematic: fsr-left.kicad_sch, LEFT selected FSR low-voltage bench frontend

Parts:
C79: 100n FSR sense; C_0805_2012Metric
C80: 100n OPA bypass; C_0805_2012Metric
C81: 100n ADC reservoir; C_0805_2012Metric
C82: 100n mux bypass; C_0805_2012Metric
J46: LEFT_FSR_34-00018_EXTERNAL; PinHeader_1x02_P2.54mm_Vertical
R128: 10k 1% FSR excitation; R_0805_2012Metric
R129: 1k 1% FSR return; R_0805_2012Metric
R130: 10k 0.1% FSR measure; R_0805_2012Metric
R131: 10k 1% OPA input limit; R_0805_2012Metric
R132: 1k 1% ADC isolation; R_0805_2012Metric
R133: 10k 1% ADC bleed; R_0805_2012Metric
R134: 100k enable default off; R_0805_2012Metric
U26: OPA333AIDBVR; SOT-23-5
U27: TMUX1511PWR; TSSOP-14_4.4x5mm_P0.65mm

Connections:
FSR_SAMPLE_ENABLE: R134.1, U27.1 (SEL1); also elsewhere on the board
LEFT_FSR_ADC: C81.1, R132.2, R133.1; also elsewhere on the board
LEFT_FSR_BUF: U26.1 (OUT), U26.4 (-IN), U27.2 (S1)
LEFT_FSR_EXC_CABLE: J46.1, R128.2; also elsewhere on the board
LEFT_FSR_ISO_OUT: R132.1, U27.3 (D1)
LEFT_FSR_OP_IN: R131.2, U26.3 (+IN)
LEFT_FSR_RETURN_CABLE: J46.2, R129.1; also elsewhere on the board
LEFT_FSR_SENSE: C79.1, R129.2, R130.1, R131.1; also elsewhere on the board
LOGIC3V3_EXT: C82.1, U27.14 (VDD); also elsewhere on the board
MCU_VREF: C80.1, R128.1, U26.5 (V+); also elsewhere on the board
PGND: C79.2, C80.2, C81.2, C82.2, R130.2, R133.2, R134.2, U26.2 (V-), U27.4 (SEL2), U27.7 (GND), U27.10 (SEL3), U27.13 (SEL4); also elsewhere on the board

Notes on the sheet:
Interlink 34-00018 external 402 short-tail pad; connector mate / mechanics UNQUALIFIED.
LOW-VOLTAGE BENCH ONLY. TVS / clamps candidates, NOT battery-short protection. No torque-sign guard.
MCU_VREF = excitation / OPA supply; LOGIC3V3_EXT = mux supply. PGND common; no isolation of ground.
Enable PE5 pin4 default low; 20ms blanking + plausibility pending firmware / bench validation.
Binary switch authoritative by firmware CONTRACT ONLY. Invalid FSR cannot authorize positive torque.
PWR_FLAG MCU_VREF: MCU internal reference output on U17 pin 36

Schematic: fsr-protection-left.kicad_sch, LEFT FSR candidate ESD and secondary clamps - unqualified

Parts:
D38, D39: PESD3V3U1UL; D_SOD-882
D40: BAT54S; SOT-23

Connections:
LEFT_FSR_EXC_CABLE: D38.1 (A1); also elsewhere on the board
LEFT_FSR_RETURN_CABLE: D39.1 (A1); also elsewhere on the board
LEFT_FSR_SENSE: D40.3 (COM); also elsewhere on the board
MCU_VREF: D40.2 (K); also elsewhere on the board
PGND: D38.2 (A2), D39.2 (A2), D40.1 (A); also elsewhere on the board

Notes on the sheet:
Connector TVS: cathode1 cable, anode2 ground. BAT54S: anode1 ground, cathode2 rail, junction3 sense.
NOT QUALIFIED: clamp voltage, leakage, negative pulses, rail sink / powered-off backfeed, ESD energy.
Battery short is a RELEASE BLOCKER. No external cable driver; segregated current-limited LV bench only.
TVS is NOT a 3.3V limiter. Secondary clamp can backfeed MCU_VREF. No vehicle energization authorization.

Schematic: fsr-right.kicad_sch, RIGHT selected FSR low-voltage bench frontend

Parts:
C83: 100n FSR sense; C_0805_2012Metric
C84: 100n OPA bypass; C_0805_2012Metric
C85: 100n ADC reservoir; C_0805_2012Metric
C86: 100n mux bypass; C_0805_2012Metric
J47: RIGHT_FSR_34-00018_EXTERNAL; PinHeader_1x02_P2.54mm_Vertical
R135: 10k 1% FSR excitation; R_0805_2012Metric
R136: 1k 1% FSR return; R_0805_2012Metric
R137: 10k 0.1% FSR measure; R_0805_2012Metric
R138: 10k 1% OPA input limit; R_0805_2012Metric
R139: 1k 1% ADC isolation; R_0805_2012Metric
R140: 10k 1% ADC bleed; R_0805_2012Metric
R141: 100k enable default off; R_0805_2012Metric
U28: OPA333AIDBVR; SOT-23-5
U29: TMUX1511PWR; TSSOP-14_4.4x5mm_P0.65mm

Connections:
FSR_SAMPLE_ENABLE: R141.1, U29.1 (SEL1); also elsewhere on the board
LOGIC3V3_EXT: C86.1, U29.14 (VDD); also elsewhere on the board
MCU_VREF: C84.1, R135.1, U28.5 (V+); also elsewhere on the board
PGND: C83.2, C84.2, C85.2, C86.2, R137.2, R140.2, R141.2, U28.2 (V-), U29.4 (SEL2), U29.7 (GND), U29.10 (SEL3), U29.13 (SEL4); also elsewhere on the board
RIGHT_FSR_ADC: C85.1, R139.2, R140.1; also elsewhere on the board
RIGHT_FSR_BUF: U28.1 (OUT), U28.4 (-IN), U29.2 (S1)
RIGHT_FSR_EXC_CABLE: J47.1, R135.2; also elsewhere on the board
RIGHT_FSR_ISO_OUT: R139.1, U29.3 (D1)
RIGHT_FSR_OP_IN: R138.2, U28.3 (+IN)
RIGHT_FSR_RETURN_CABLE: J47.2, R136.1; also elsewhere on the board
RIGHT_FSR_SENSE: C83.1, R136.2, R137.1, R138.1; also elsewhere on the board

Notes on the sheet:
Interlink 34-00018 external 402 short-tail pad; connector mate / mechanics UNQUALIFIED.
LOW-VOLTAGE BENCH ONLY. TVS / clamps candidates, NOT battery-short protection. No torque-sign guard.
MCU_VREF = excitation / OPA supply; LOGIC3V3_EXT = mux supply. PGND common; no isolation of ground.
Enable PE5 pin4 default low; 20ms blanking + plausibility pending firmware / bench validation.
Binary switch authoritative by firmware CONTRACT ONLY. Invalid FSR cannot authorize positive torque.

Schematic: fsr-protection-right.kicad_sch, RIGHT FSR candidate ESD and secondary clamps - unqualified

Parts:
D41, D42: PESD3V3U1UL; D_SOD-882
D43: BAT54S; SOT-23

Connections:
MCU_VREF: D43.2 (K); also elsewhere on the board
PGND: D41.2 (A2), D42.2 (A2), D43.1 (A); also elsewhere on the board
RIGHT_FSR_EXC_CABLE: D41.1 (A1); also elsewhere on the board
RIGHT_FSR_RETURN_CABLE: D42.1 (A1); also elsewhere on the board
RIGHT_FSR_SENSE: D43.3 (COM); also elsewhere on the board

Notes on the sheet:
Connector TVS: cathode1 cable, anode2 ground. BAT54S: anode1 ground, cathode2 rail, junction3 sense.
NOT QUALIFIED: clamp voltage, leakage, negative pulses, rail sink / powered-off backfeed, ESD energy.
Battery short is a RELEASE BLOCKER. No external cable driver; segregated current-limited LV bench only.
TVS is NOT a 3.3V limiter. Secondary clamp can backfeed MCU_VREF. No vehicle energization authorization.

Schematic: entry-main.kicad_sch, MAIN back-to-back candidate - hardware inhibited

Parts:
C400: 1u 10V X7R effective >=0.22u; C_0603_1608Metric
C401: 100n 25V C0G 5% CDIV1; C_0805_2012Metric
C402: 470n 25V C0G 5% CDIV2; C_0805_2012Metric
Q400, Q401: IRFP4568PbF 150V; TO-247-3_Vertical
R400: 20k 1% PXFR; R_0805_2012Metric
R401: 10k EN default OFF; R_0805_2012Metric
R402: 0R FIXED INHIBIT - no operational command source; R_0805_2012Metric
R403, R405: 3R3 1% gate; R_0805_2012Metric
R404, R406: 100k 1% G-S default OFF; R_0805_2012Metric
U400: TPSI3052DWZR; SOIC-8_5.3x5.3mm_P1.27mm

Connections:
BUS_SHUNT_HI: Q401.2 (D); also elsewhere on the board
CTRL3V3: C400.1, U400.3 (VDDP); also elsewhere on the board
ENTRY_FUSED: Q400.2 (D); also elsewhere on the board
MAIN_EN: R401.1, R402.1, U400.1 (EN)
MAIN_PXFR: R400.1, U400.2 (PXFR)
MAIN_SOURCE: C402.2, Q400.3 (S), Q401.3 (S), R404.2, R406.2, U400.5 (VSSS)
MAIN_VDDH: C401.1, U400.7 (VDDH)
MAIN_VDDM: C401.2, C402.1, U400.6 (VDDM)
MAIN_VDRV: R403.1, R405.1, U400.8 (VDRV)
PGND: C400.2, R400.2, R401.2, R402.2, U400.4 (VSSP); also elsewhere on the board
Q400_GATE: Q400.1 (G), R403.2, R404.1
Q401_GATE: Q401.1 (G), R405.2, R406.1

Notes on the sheet:
NO ENERGIZE: 0R EN inhibit fitted; sequencer and CTRL3V3 buck NOT IMPLEMENTED.
150V IRFP4568PbF TO-247AC G=1 D=2 S=3 (PD-96175). SOA, clamp and thermal qualification remain OPEN.
Common-source node floats: NEVER PGND. CDIV2/CDIV1 worst 470*.95/(100*1.05)=4.25 > 3.
EN not gate feedback. No MAIN_PROVEN, timeout, PM-quiet or current detector claimed.
PWR_FLAG MAIN_SOURCE: floating common-source node of Q400/Q401

Schematic: entry-pre.kicad_sch, PRE back-to-back candidate - hardware inhibited

Parts:
C410: 1u 10V X7R effective >=0.22u; C_0603_1608Metric
C411: 100n 25V C0G 5% CDIV1; C_0805_2012Metric
C412: 470n 25V C0G 5% CDIV2; C_0805_2012Metric
Q402, Q403: IRFP4568PbF 150V; TO-247-3_Vertical
R410: 20k 1% PXFR; R_0805_2012Metric
R411: 10k EN default OFF; R_0805_2012Metric
R412: 0R FIXED INHIBIT - no operational command source; R_0805_2012Metric
R413, R415: 3R3 1% gate; R_0805_2012Metric
R414, R416: 100k 1% G-S default OFF; R_0805_2012Metric
U401: TPSI3052DWZR; SOIC-8_5.3x5.3mm_P1.27mm

Connections:
CTRL3V3: C410.1, U401.3 (VDDP); also elsewhere on the board
ENTRY_FUSED: Q402.2 (D); also elsewhere on the board
PGND: C410.2, R410.2, R411.2, R412.2, U401.4 (VSSP); also elsewhere on the board
PRECHARGE_R: Q403.2 (D); also elsewhere on the board
PRE_EN: R411.1, R412.1, U401.1 (EN)
PRE_PXFR: R410.1, U401.2 (PXFR)
PRE_SOURCE: C412.2, Q402.3 (S), Q403.3 (S), R414.2, R416.2, U401.5 (VSSS)
PRE_VDDH: C411.1, U401.7 (VDDH)
PRE_VDDM: C411.2, C412.1, U401.6 (VDDM)
PRE_VDRV: R413.1, R415.1, U401.8 (VDRV)
Q402_GATE: Q402.1 (G), R413.2, R414.1
Q403_GATE: Q403.1 (G), R415.2, R416.1

Notes on the sheet:
NO ENERGIZE: 0R EN inhibit fitted; sequencer and CTRL3V3 buck NOT IMPLEMENTED.
150V IRFP4568PbF TO-247AC G=1 D=2 S=3 (PD-96175). SOA, clamp and thermal qualification remain OPEN.
Common-source node floats: NEVER PGND. CDIV2/CDIV1 worst 470*.95/(100*1.05)=4.25 > 3.
EN not gate feedback. No MAIN_PROVEN, timeout, PM-quiet or current detector claimed.
PWR_FLAG PRE_SOURCE: floating common-source node of Q402/Q403

Schematic: ctrl-supply.kicad_sch, CTRL3V3 pack-side buck - unqualified, enables inhibited

Parts:
C500, C501: 2.2u 200V X7R 22252C225KAT2A; C_2225_5664Metric
C502: 2.2n 50V GCM155R71H222KA37D; C_0402_1005Metric
C503, C504: 22u 25V TMK325B7226KMHT; C_1210_3225Metric
C505: 3.3n 100V CGA3E2X7R2A332K080AA; C_0603_1608Metric
C506: 330p 50V C0G 5%; C_0805_2012Metric
D500: S1J-E3/61T 600V 1A; D_SMA
L500: 68u MSS1246T-683MLC 20%; L_Coilcraft_MSS1246T-XXX
R500: 27.4k 1% 0.1W; R_0805_2012Metric
R501: 87.3k 1% 0.1W; R_0805_2012Metric
R502: 49.9k 1% RG1608P-4992-B-T5; R_0603_1608Metric
R503: 150k 1% 0.1W >=100V; R_0805_2012Metric
R504: 1M 1% 0.1W >=100V; R_0805_2012Metric
R505: 52.3k 1% 0.1W; R_0805_2012Metric
U500: LM5164DDAR; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm

Connections:
CTRL3V3: C503.1, C504.1, C505.2, L500.2, R501.1; also elsewhere on the board
CTRL_BST: C502.1, U500.7 (BST)
CTRL_FB: C506.2, R501.2, R502.1, U500.5 (FB)
CTRL_PG: U500.6 (PGOOD); also elsewhere on the board
CTRL_RAMP: C505.1, C506.1, R503.2
CTRL_RAW: C500.1, C501.1, D500.1 (K), R504.1, U500.2 (VIN)
CTRL_RON: R500.1, U500.4 (RON)
CTRL_SW: C502.2, L500.1, R503.1, U500.8 (SW)
CTRL_UVLO: R504.2, R505.1, U500.3 (EN_UVLO)
ENTRY_FUSED: D500.2 (A); also elsewhere on the board
PGND: C500.2, C501.2, C503.2, C504.2, R500.2, R502.2, R505.2, U500.1 (GND), U500.9 (EP); also elsewhere on the board

Notes on the sheet:
36-58.4V pack -> ENTRY_FUSED -> D500 -> CTRL_RAW. Upstream MAIN; no bus dependency.
TI LM5164 SNVSAU4D adapted Type-3 network. 0.8W PACK INPUT acceptance cap, NOT output rating.
NOT SAFE TO ENERGIZE. No PGOOD interlock or whole-system reverse/OV protection claimed.
PGOOD to CTRL_PG: rail-partition interlock; no MAIN proof claimed. U400/U401 EN 0R inhibits remain fitted.
200V input ceramics: effective C / surge / damping OPEN; 2225 footprint candidate, layout not qualified.
D500 protects this positive supply branch only; no full-system reverse-polarity or transient proof.
PWR_FLAG CTRL_RAW: DC_LINK through D500 S1J rectifier - passive, not a driver
PWR_FLAG CTRL3V3: U500 LM5164 buck output via L500; SW is not a power-OUT

Schematic: rail-partition.kicad_sch, Rail partition: SINK12 always-on, DRIVE12/MCU3V3 delayed an…

Parts:
U501: LM5164DDAR; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm
U502: AP63203WU; TSOT-23-6
U503: TLV1701AIDBVR; SOT-23-5
U504: SN74LVC1G74DCUR; VSSOP-8_2.3x2mm_P0.5mm
U505, U510: SN74LVC1G08DBVR; SOT-23-5

Connections:
CTRL_PG: U510.1; also elsewhere on the board
DC_LINK: U501.2 (VIN); also elsewhere on the board
DRIVE12: U502.3 (VIN); also elsewhere on the board
DRIVE_BST: U501.7 (BST); also elsewhere on the board
DRIVE_EN: U504.1 (CLK), U510.4; also elsewhere on the board
DRIVE_EN_GATED: U504.5 (Q), U505.1; also elsewhere on the board
DRIVE_FAULT: U504.6 (CLR_N), U505.4; also elsewhere on the board
DRIVE_FB: U501.5 (FB); also elsewhere on the board
DRIVE_LATCH_D: U504.2 (D); also elsewhere on the board
DRIVE_NQ: U504.3 (Q_N); also elsewhere on the board
DRIVE_OV_SENSE: U503.3 (IN-); also elsewhere on the board
DRIVE_OV_TRIP: U503.4 (OUT); also elsewhere on the board
DRIVE_PG: U501.6 (PGOOD), U505.2; also elsewhere on the board
DRIVE_RON: U501.4 (RON); also elsewhere on the board
DRIVE_SW: U501.8 (SW); also elsewhere on the board
DRIVE_UVLO: U501.3 (EN_UVLO); also elsewhere on the board
LOGIC3V3_EXT: U502.1 (FB); also elsewhere on the board
MAIN_PROVEN_IN: U510.2; also elsewhere on the board
MCU3V3_EN: U502.2 (EN); also elsewhere on the board
MCU_BST: U502.6 (BST); also elsewhere on the board
MCU_SW: U502.5 (SW); also elsewhere on the board
PGND: U501.1 (GND), U501.9 (EP), U502.4 (GND), U503.2 (V-), U504.4 (GND), U505.3 (GND), U510.3 (GND); also elsewhere on the board
REF2V5: U503.1 (IN+); also elsewhere on the board
SAFETY3V3: U504.7 (PRE_N), U504.8 (VCC), U505.5 (VCC), U510.5 (VCC); also elsewhere on the board
SINK12: U503.5 (V+); also elsewhere on the board

Notes on the sheet:
NOT SAFE TO ENERGIZE. Partition of the former single AUX12V; no release or energization claim.
SINK12 = U3 R-78HB12-0.5 output: always bus-fed sink/safety cluster. 1.1 W input envelope, pre-proof only.
DRIVE12 = bus LM5164 (TI 12V reference values). LOGIC3V3_EXT = AP63203 from DRIVE12. Both EN held low by 100k.
DRIVE_EN = CTRL_PG AND MAIN_PROVEN_IN. MAIN_PROVEN_IN has a FITTED 0R inhibit to PGND.
U510 is powered from SAFETY3V3, the always-on safety rail. Losing it floats Y: 100k pulldowns keep both EN low. Its output is DRIVE_EN, which now clocks the fault latch (U504) rather than driving the buck directly.
Enable chain: DRIVE_EN -> U504 clock -> Q = DRIVE_EN_GATED -> U501 EN/UVLO via R514. A latched fault holds DRIVE_EN_GATED low, so the buck stays disabled until the manual reset releases CLR_N.
U501 is TI figure 7-1 (12 V/1 A/300 kHz) with RRON=100k and RFB1/RFB2=453k/49.9k. PGOOD drives DRIVE_PG only.
U503 output asserts DRIVE_OV_TRIP low when DRIVE12 exceeds 2.5V*(R523+R524)/R524 = 16.25 V nominal. Independent of the LM5164 FB node, so an open FB divider cannot hide the fault. It drives the latch (U504), not the buck directly: see RAIL-16.
U504 is the DRIVE12 fault latch: Q holds the enable off after one OVP trip until CLR_N is released. Powered from SAFETY3V3 so it survives a DRIVE12 collapse; PRE_N tied high so it cannot be set remotely.
U505 gives DRIVE_PG its consumer: any PGOOD-low clears the latch, so a buck that drops out of regulation cannot silently keep the enable asserted.
U502 pin map per Diodes TSOT26 table; FB tied to VOUT for the fixed 3.3 V variant.
PWR_FLAG DRIVE12: U501 LM5164 buck output via L501; SW is not a power-OUT

Schematic: rail-passives.kicad_sch, Rail partition passive networks - unqualified

Parts:
C510, C511: 2.2u 200V X7R 22252C225KAT2A; C_2225_5664Metric
C512: 2.2n 50V GCM155R71H222KA37D; C_0402_1005Metric
C513, C514: 22u 25V TMK325B7226KMHT; C_1210_3225Metric
C515: 3.3n 100V CGA3E2X7R2A332K080AA; C_0603_1608Metric
C516: 56p 50V C0G; C_0805_2012Metric
C517: 10u 25V X7R; C_0805_2012Metric
C518, C519: 22u 16V X7R; C_1206_3216Metric
C520, C521: 100n 25V X7R; C_0805_2012Metric
C523: 100p 50V C0G OVP sense filter; C_0805_2012Metric
D520: SS14 40V 1A OVP trip wired-OR; D_SMA
D521: SS14 40V 1A PGOOD wired-OR; D_SMA
D522: SS14 40V 1A manual reset wired-OR; D_SMA
J48: Conn_01x02 reset header, SW to PGND; PinHeader_1x02_P2.54mm_Vertical
L501: 68u SPM10065VC-680M-D 20% AEC-Q200; L_TDK_SPM10065VC-D
L502: 3.9u 2A; L_Bourns_SRN6045TA
R510: 100k 1% 0.1W TI reference; R_0805_2012Metric
R511, R513: 453k 1% 0.1W TI reference; R_0805_2012Metric
R512: 49.9k 1% RG1608P-4992-B-T5; R_0603_1608Metric
R514: 82k 1% 0.1W >=100V; R_0805_2012Metric
R515, R517: 100k 1% DELAY EN pulldown; R_0805_2012Metric
R516: 47k 1% EN series; R_0805_2012Metric
R518: 100k 1% MAIN_PROVEN default low; R_0805_2012Metric
R519: 0R FIXED INHIBIT - no MAIN_PROVEN detector fitted; R_0805_2012Metric
R520: 10k CTRL PGOOD pullup; R_0805_2012Metric
R521: 47k 1% DRIVE_PG pullup (PGOOD abs max 14V); R_0805_2012Metric
R523: 649k 0.1% DRIVE12 OVP upper leg; R_0805_2012Metric
R524: 118k 0.1% DRIVE12 OVP lower leg; R_0805_2012Metric
R525: 100k 1% DRIVE latch D tied low; R_0805_2012Metric
R526: 47k 1% DRIVE_FAULT pullup; R_0805_2012Metric
R527: 100k 1% manual reset series (SW to PGND); R_0805_2012Metric
R528: 10k 1% DRIVE_NQ load, keeps Q_N defined; R_0805_2012Metric

Connections:
CTRL3V3: R520.1; also elsewhere on the board
CTRL_PG: R520.2; also elsewhere on the board
DC_LINK: C510.1, C511.1; also elsewhere on the board
DRIVE12: C513.1, C514.1, C515.2, C517.1, L501.2, R511.1, R523.1; also elsewhere on the board
DRIVE_BST: C512.1; also elsewhere on the board
DRIVE_EN: R516.1; also elsewhere on the board
DRIVE_EN_GATED: R514.1; also elsewhere on the board
DRIVE_FAULT: D520.2 (A), D521.2 (A), D522.2 (A), R526.2, R527.1; also elsewhere on the board
DRIVE_FB: C516.2, R511.2, R512.1; also elsewhere on the board
DRIVE_LATCH_D: R525.1; also elsewhere on the board
DRIVE_NQ: R528.1; also elsewhere on the board
DRIVE_OV_SENSE: C523.1, R523.2, R524.1; also elsewhere on the board
DRIVE_OV_TRIP: D520.1 (K); also elsewhere on the board
DRIVE_PG: D521.1 (K), R521.2; also elsewhere on the board
DRIVE_RAMP: C515.1, C516.1, R513.2
DRIVE_RESET_SW: D522.1 (K), J48.1, R527.2
DRIVE_RON: R510.1; also elsewhere on the board
DRIVE_SW: C512.2, L501.1, R513.1; also elsewhere on the board
DRIVE_UVLO: R514.2, R515.1; also elsewhere on the board
LOGIC3V3_EXT: C518.1, C519.1, L502.2; also elsewhere on the board
MAIN_PROVEN_IN: R518.1, R519.1; also elsewhere on the board
MCU3V3_EN: R516.2, R517.1; also elsewhere on the board
MCU_BST: C520.1; also elsewhere on the board
MCU_SW: C520.2, L502.1; also elsewhere on the board
PGND: C510.2, C511.2, C513.2, C514.2, C517.2, C518.2, C519.2, C521.2, C523.2, J48.2, R510.2, R512.2, R515.2, R517.2, R518.2, R519.2, R524.2, R525.2, R528.2; also elsewhere on the board
SAFETY3V3: C521.1, R526.1; also elsewhere on the board
SINK12: R521.1; also elsewhere on the board

Notes on the sheet:
R519 0R keeps MAIN_PROVEN_IN low, so DRIVE_EN stays low: both delayed rails are OFF by construction.
U501 PGOOD drives DRIVE_PG only: the always-on ANALOG_OK chain is no longer gated by a delayed rail.

Board: 4 copper layers, 397 parts (0 on the bottom side), 226 nets, no tracks yet.

File hardware/powerboard-reva/review-bom.csv (part):

reference,value,footprint,sheet
U1,DRV8353SRTAT,Package_DFN_QFN:QFN-40-1EP_6x6mm_P0.5mm_EP4.6x4.6mm,gen-driver
C1,47n 100V X7R,Capacitor_SMD:C_0805_2012Metric,gen-driver
C2,1u 16V X7R,Capacitor_SMD:C_0805_2012Metric,gen-driver
C3,1u 16V X7R,Capacitor_SMD:C_0805_2012Metric,gen-driver
C4,1u 10V X7R,Capacitor_SMD:C_0603_1608Metric,gen-driver
C5,100n 25V X7R,Capacitor_SMD:C_0805_2012Metric,gen-driver
C6,10u 25V X7R,Capacitor_SMD:C_0805_2012Metric,gen-driver
C7,100n 10V X7R,Capacitor_SMD:C_0603_1608Metric,gen-driver
R1,100k,Resistor_SMD:R_0805_2012Metric,gen-driver
R2,10k,Resistor_SMD:R_0805_2012Metric,gen-driver
R3,10k,Resistor_SMD:R_0805_2012Metric,gen-driver
R4,10k,Resistor_SMD:R_0805_2012Metric,gen-driver
Q1,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,gen-bridge
R5,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,gen-bridge
R6,100k G-S,Resistor_SMD:R_0805_2012Metric,gen-bridge
Q2,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,gen-bridge
R7,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,gen-bridge
R8,100k G-S,Resistor_SMD:R_0805_2012Metric,gen-bridge
R9,2m 1% 3W WSLP2512,Resistor_SMD:R_2512_6332Metric,gen-bridge
C8,1u 100V X7R,Capacitor_SMD:C_0805_2012Metric,gen-bridge
Q3,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,gen-bridge
R10,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,gen-bridge
R11,100k G-S,Resistor_SMD:R_0805_2012Metric,gen-bridge
Q4,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,gen-bridge
R12,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,gen-bridge
R13,100k G-S,Resistor_SMD:R_0805_2012Metric,gen-bridge
R14,2m 1% 3W WSLP2512,Resistor_SMD:R_2512_6332Metric,gen-bridge
C9,1u 100V X7R,Capacitor_SMD:C_0805_2012Metric,gen-bridge
Q5,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,gen-bridge
R15,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,gen-bridge
R16,100k G-S,Resistor_SMD:R_0805_2012Metric,gen-bridge
Q6,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,gen-bridge
R17,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,gen-bridge
R18,100k G-S,Resistor_SMD:R_0805_2012Metric,gen-bridge
R19,2m 1% 3W WSLP2512,Resistor_SMD:R_2512_6332Metric,gen-bridge
C10,1u 100V X7R,Capacitor_SMD:C_0805_2012Metric,gen-bridge
U2,DRV8353SRTAT,Package_DFN_QFN:QFN-40-1EP_6x6mm_P0.5mm_EP4.6x4.6mm,hub-driver
C11,47n 100V X7R,Capacitor_SMD:C_0805_2012Metric,hub-driver
C12,1u 16V X7R,Capacitor_SMD:C_0805_2012Metric,hub-driver
C13,1u 16V X7R,Capacitor_SMD:C_0805_2012Metric,hub-driver
C14,1u 10V X7R,Capacitor_SMD:C_0603_1608Metric,hub-driver
C15,100n 25V X7R,Capacitor_SMD:C_0805_2012Metric,hub-driver
C16,10u 25V X7R,Capacitor_SMD:C_0805_2012Metric,hub-driver
C17,100n 10V X7R,Capacitor_SMD:C_0603_1608Metric,hub-driver
R20,100k,Resistor_SMD:R_0805_2012Metric,hub-driver
R21,10k,Resistor_SMD:R_0805_2012Metric,hub-driver
R22,10k,Resistor_SMD:R_0805_2012Metric,hub-driver
R23,10k,Resistor_SMD:R_0805_2012Metric,hub-driver
Q7,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,hub-bridge
R24,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,hub-bridge
R25,100k G-S,Resistor_SMD:R_0805_2012Metric,hub-bridge
Q8,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,hub-bridge
R26,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,hub-bridge
R27,100k G-S,Resistor_SMD:R_0805_2012Metric,hub-bridge
R28,2m 1% 3W WSLP2512,Resistor_SMD:R_2512_6332Metric,hub-bridge
C18,1u 100V X7R,Capacitor_SMD:C_0805_2012Metric,hub-bridge
Q9,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,hub-bridge
R29,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,hub-bridge
R30,100k G-S,Resistor_SMD:R_0805_2012Metric,hub-bridge
Q10,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,hub-bridge
R31,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,hub-bridge
R32,100k G-S,Resistor_SMD:R_0805_2012Metric,hub-bridge
R33,2m 1% 3W WSLP2512,Resistor_SMD:R_2512_6332Metric,hub-bridge
C19,1u 100V X7R,Capacitor_SMD:C_0805_2012Metric,hub-bridge
Q11,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,hub-bridge
R34,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,hub-bridge
R35,100k G-S,Resistor_SMD:R_0805_2012Metric,hub-bridge
Q12,CSD19532Q5B,Package_TO_SOT_SMD:TDSON-8-1,hub-bridge
R36,3R3 1% gate,Resistor_SMD:R_0805_2012Metric,hub-bridge
R37,100k G-S,Resistor_SMD:R_0805_2012Metric,hub-bridge
R38,2m 1% 3W WSLP2512,Resistor_SMD:R_2512_6332Metric,hub-bridge
C20,1u 100V X7R,Capacitor_SMD:C_0805_2012Metric,hub-bridge
J1,BUS_TEST_ONLY_NOT_SOURCE_INPUT,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,external-boundaries
J2,MCU_RAIL_TEST_ONLY_NOT_INPUT,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,external-boundaries
J3,GEN_MACHINE_PHASES,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical,external-boundaries
J4,HUB_MACHINE_PHASES,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical,external-boundaries
J5,SAFETY_FAULT_CHAIN_NC,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,external-boundaries
C21,100u 100V,Capacitor_THT:CP_Radial_D10.0mm_P5.00mm,external-boundaries
U3,R-78HB12-0.5,Converter_DCDC:Converter_DCDC_RECOM_R-78HB-0.5_THT,aux-supply
U4,TLV76033DBZR,Package_TO_SOT_SMD:SOT-23,aux-supply
C22,3.3u 100V GRM32ER72A335KA35L,Capacitor_SMD:C_1210_3225Metric,aux-supply
C23,10u 25V GRM21BR61E106KA73L,Capacitor_SMD:C_0805_2012Metric,aux-supply
C24,1u 25V GRM21BR71E105KA99L,Capacitor_SMD:C_0805_2012Metric,aux-supply
R39,1k 1% CRCW08051K00FKEA,Resistor_SMD:R_0805_2012Metric,aux-supply
U5,LM4040AIM3-2.5/NOPB,Package_TO_SOT_SMD:SOT-23,aux-supply
R40,4k7 1% CRCW08054K70FKEA,Resistor_SMD:R_0805_2012Metric,aux-supply
C25,100n 25V GRM21BR71E104KA01L,Capacitor_SMD:C_0805_2012Metric,aux-supply
U6,LM339BIDR,Package_SO:SOIC-14_3.9x8.7mm_P1.27mm,protection-comparators
R41,112k 0.1% ERA-6AEB1123V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R42,113k 0.1% ERA-6AEB1133V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R43,10k 0.1% ERA-6AEB103V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R44,330k 0.1% ERA-6AEB334V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R45,1k 1% CRCW08051K00FKEA,Resistor_SMD:R_0805_2012Metric,protection-comparators
R46,30k 0.1% ERA-6AEB303V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R47,10k 0.1% ERA-6AEB103V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R48,2k 0.1% ERA-6AEB202V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R49,10k 0.1% ERA-6AEB103V,Resistor_SMD:R_0805_2012Metric,protection-comparators
R50,10k 1% CRCW080510K0FKEA,Resistor_SMD:R_0805_2012Metric,protection-comparators
R51,4k7 1% CRCW08054K70FKEA,Resistor_SMD:R_0805_2012Metric,protection-comparators
C26,100p C0G GRM21A5C1H101JA01D,Capacitor_SMD:C_0805_2012Metric,protection-comparators
C27,100n 25V GRM21BR71E104KA01L,Capacitor_SMD:C_0805_2012Metric,protection-comparators
U7,SN74LVC1G74DCUR,Package_SO:VSSOP-8_2.3x2mm_P0.5mm,fault-latch
U8,SN74LVC1G74DCUR,Package_SO:VSSOP-8_2.3x2mm_P0.5mm,fault-latch
U9,TPS3823-33DBVR,Package_TO_SOT_SMD:SOT-23-5,fault-latch
R52,10k 1% CRCW080510K0FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R53,10k 1% CRCW080510K0FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R54,1k 1% CRCW08051K00FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R55,10k 1% CRCW080510K0FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
C28,10n 5% C0G GRM21A5C1H103JA01D,Capacitor_SMD:C_0805_2012Metric,fault-latch
R56,10k 1% CRCW080510K0FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R57,10k 1% CRCW080510K0FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R58,100k CRCW0805100KFKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R59,100k CRCW0805100KFKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R60,1k 1% CRCW08051K00FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
R61,1k 1% CRCW08051K00FKEA,Resistor_SMD:R_0805_2012Metric,fault-latch
C29,100n 25V GRM21BR71E104KA01L,Capacitor_SMD:C_0805_2012Metric,fault-latch
C30,100n 25V GRM21BR71E104KA01L,Capacitor_SMD:C_0805_2012Metric,fault-latch
C31,100n 25V GRM21BR71E104KA01L,Capacitor_SMD:C_0805_2012Metric,fault-latch
U11,SN74LVC3G17DCUR,Package_SO:VSSOP-8_2.3x2mm_P0.5mm,fault-interfaces
U12,SN74LVC3G17DCUR,Package_SO:VSSOP-8_2.3x2mm_P0.5mm,fault-interfaces
U13,SN74LVC1G11DBVR,Package_TO_SOT_SMD:SOT-23-6,fault-interfaces
U14,SN74LVC1G11DBVR,Package_TO_SOT_SMD:SOT-23-6,fault-interfaces
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